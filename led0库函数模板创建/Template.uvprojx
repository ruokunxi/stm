# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;D:\stm32_project\APP\LED;D:\stm32_project\APP\BEEP;D:\stm32_project\APP\system;D:\stm32_project\APP\Systick;D:\stm32_project\APP\KEY;D:\stm32_project\APP\EXTI;D:\stm32_project\APP\UART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_usart.c
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group APP
    D:/stm32_project/APP/LED/: led.c
    D:/stm32_project/APP/BEEP/: beep.c
    D:/stm32_project/APP/system/: system.h
    D:/stm32_project/APP/Systick/: systick.c
    D:/stm32_project/APP/KEY/: key.c
    D:/stm32_project/APP/EXTI/: exti.c
    D:/stm32_project/APP/UART/: uart.c
